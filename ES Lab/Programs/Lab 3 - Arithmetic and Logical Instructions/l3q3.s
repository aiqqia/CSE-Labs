	AREA RESET,DATA,READONLY
		EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA MYCODE,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0, =SRC1
	LDR R0, [R0]
	LDR R1, =SRC2
	LDR R1, [R1]
AGA	CMP R0, #0
	BEQ EXIT
UP	CMP R1, R0
	BHS CON
	B SKIP
CON	SUB R1, R1, R0
	B UP
SKIP MOV R2, R0
	MOV R0, R1
	MOV R1, R2
	B AGA
EXIT LDR R2, =GCD
	STR R1, [R2]
	LDR R0, =SRC1
	LDR R0, [R0]
	LDR R1, =SRC2
	LDR R1, [R1]
	MUL R0, R0, R1
	LDR R1, =GCD
	LDR R1, [R1]
	LDR R2, =0
UP2 CMP R0, R1
	BCC STO
	SUB R0, R1
	ADD R2, #1
	B UP2
STO LDR R3, =LCM
	STR R2, [R3]
	
STOP B STOP
SRC1 DCD 6
SRC2 DCD 8
	AREA MYDATA, DATA, READWRITE
GCD	DCD 0
LCM DCD 0
	END