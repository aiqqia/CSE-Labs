	AREA RESET, CODE, READONLY
		EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	
	AREA myCode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0, =SRC1
	LDR R1, =SRC2
	LDR R2, =DST
	LDR R3, [R0]
	LDR R4, [R1]
	MOV R5, #0x0000000F
	MOV R6, #0
	MOV R7, #0
UP	BL ADDN
	ADD R12, R3, R4
	CMP R12, #0
	BNE UP
	CMP R6, #0
	BEQ GO
	LSL R6, R10
	ADD R11, R6
GO	STR R11, [R2]

STOP 	B STOP

ADDN	AND R8, R3, R5
	AND R9, R4, R5
	ADD R7, R8, R9
	ADD R7, R6
	CMP R7, #10
	BCC STO
	SUB R7, #10
	MOV R6, #1
STO	LSL R7, R10
	ADD R11, R7
	ADD R10, #4
	MOV R7, #0
	LSR R3, #4
	LSR R4, #4
	BX LR
SRC1	DCD 0x11111111
SRC2	DCD 0x22222222
	AREA MYDATA, DATA, READWRITE
DST DCD 0x0
	END